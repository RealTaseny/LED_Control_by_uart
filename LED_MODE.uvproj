# Keil uVision project LED_MODE.uvproj, settings and files
target DEBUG (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LED_MODE +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\Sys
  group User
    ./User/: main.c
  group Sys
    ./Sys/: delay.c Init.c PWM.c Uart.c ADC_wyh.c ADC_wyh.h Vofa_wyh.c Vofa_wyh.h headfile_wyh.h
  group Driver
    ./Driver/: key.c LED.c
